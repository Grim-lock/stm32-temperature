# Keil uVision project oled.uvprojx, settings and files
target oled (6160000::V6.16::ARMCLANG)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: temp +hex
  AfterMake: fromelf --bin --output ./output/temp.bin ./output/temp.axf
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103x6
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\ssd1306
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Application/MDK-ARM
    ./: startup_stm32f103x6.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_gpio.c stm32f1xx_hal_uart.c stm32f1xx_hal_dma.c stm32f1xx_hal_rcc.c stm32f1xx_hal_cortex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group ssd1306
    ../ssd1306/: fonts.c ssd1306.c
software components: CMSIS:CORE 5.5.0
